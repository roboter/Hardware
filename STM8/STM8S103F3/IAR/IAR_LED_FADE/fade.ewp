# IAR project fade.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: D:\projects\HARDWARE\STM8\STM8S_StdPeriph_Lib\Libraries\STM8S_StdPeriph_Driver\inc; D:\projects\HARDWARE\STM8\STM8S_StdPeriph_Lib\Libraries\STM8S_StdPeriph_Driver\src; C:\Users\roboter\Documents\GitHub\HardwareModules\STM8\STM8S103F3\IAR_LED_FADE\lib
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: fade.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
