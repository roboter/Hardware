# IAR project dfu.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F20xxK GD GD32F20xxK
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: GD32F20X_CL; USE_USB_FS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\CMSIS\GD\GD32F20x\Include; ..\..\..\..\..\Firmware\GD32F20x_standard_peripheral\Include; D:\GD32F20x_Firmware_Library_V2.0.0\GD32F20x_Firmware_Library\Firmware\GD32F20x_usbfs_library\device\class\hid\Include; ..\..\..\..\..\Firmware\GD32F20x_usbfs_library\device\class\dfu\Include; ..\..\..\..\..\Firmware\GD32F20x_usbfs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32F20x_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32F20x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_Audio.srec
  ILINK.IlinkOutputFile: dfu.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../src/: app.c exmc_nandflash.c gd25qxx.c gd32f20x_hw.c gd32f20x_it.c inter_flash_if.c nand_flash_if.c nor_flash_if.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group Doc
    ../: readme.txt
  group GD32F20x_EVAL
    ../../../../../Utilities/: gd32f20x_eval.c
  group GD32F20x_StdPeriph
    ../../../../../Firmware/GD32F20x_standard_peripheral/Source/: gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_gpio.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_spi.c gd32f20x_timer.c gd32f20x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F20x/Source/IAR/: startup_gd32f20x_cl.s
  group USB_Class
    ../../../../../Firmware/GD32F20x_usbfs_library/device/class/dfu/Source/: dfu_core.c dfu_mem.c
  group USB_Device
    ../../../../../Firmware/GD32F20x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../Firmware/GD32F20x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
