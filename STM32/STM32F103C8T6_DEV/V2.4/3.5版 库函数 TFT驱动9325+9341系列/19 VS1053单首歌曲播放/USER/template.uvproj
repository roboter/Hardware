# Keil uVision project template.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: template +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\FWLIB\inc;..\CORE;..\DELAY;..\HARDWARE\LED;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\KEY;..\TFT;..\GUI;..\24c02;..\HARDWARE\xpt2046;..\HARDWARE\sd;..\FATFS;..\HARDWARE\mp3player;..\HARDWARE\vs1053
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group DELAY
    ../DELAY/: delay.c
  group TFT
    ../TFT/: tft.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/xpt2046/: xpt2046.c
    ../HARDWARE/sd/: sd.c
    ../HARDWARE/mp3player/: mp3player.c
    ../HARDWARE/vs1053/: vs1053.c
  group GUI
    ../GUI/: GUI.C
  group 24C
    ../24c02/: 24C02.c I2C.c
  group FATFS
    ../FATFS/: diskio.c pff.c
