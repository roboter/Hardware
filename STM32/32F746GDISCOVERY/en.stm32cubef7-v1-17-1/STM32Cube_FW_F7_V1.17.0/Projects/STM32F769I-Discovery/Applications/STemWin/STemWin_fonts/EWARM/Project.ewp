# IAR project Project.ewp, settings and files
configuration STM32F769I_DISCOVERY (ARM, debug)
  General.OGChipSelectEditMenu: STM32F769NI ST STM32F769NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F769xx; USE_STM32F769I_DISCO
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\STemWin\App\generated\fonts; ..\STemWin\App\generated\images; ..\STemWin\Target; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F769I-Discovery; ..\..\..\..\..\..\Drivers\BSP\Components\otm8009a; ..\..\..\..\..\..\Middlewares\ST\STemWin\inc; ..\STemWin\Target
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f769xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f769xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f7xx_it.c
  group Application/User/STemWin
    ../STemWin/App/: font_app.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../../Drivers/BSP/Components/nt35510/: nt35510.c
  group Drivers/BSP/STM32769I-Discovery
    ../../../../../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c stm32f769i_discovery_sdram.c stm32f769i_discovery_ts.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_fmc.c
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM7_wc32_ARGB.a
  group Middlewares/STemWin/OS
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Middlewares/STemWin/Target
    ../STemWin/Target/: GUIConf.c LCDConf.c
