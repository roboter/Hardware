# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2007FFFF) IRAM(0x00000000-0x3FFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO
  c misc: --C99
  c include: ../Core/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F769I-Discovery;../../../../../../Drivers/BSP/Components/Common;../STemWin/Target;../../../../../../Middlewares/ST/STemWin/inc;../STemWin/App/generated
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_sram.c stm32f7xx_ll_usb.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_sdram.c stm32f7xx_hal_flash.c stm32f7xx_hal_i2s.c stm32f7xx_hal_uart.c stm32f7xx_hal_dsi.c stm32f7xx_ll_fmc.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_sai.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma.c stm32f7xx_hal_i2c.c stm32f7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Application/User/Core
    ../Core/Src/: main.c stm32f7xx_it.c
  group Drivers/BSP/STM327F769I_Discovery
    ../../../../../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery_sdram.c stm32f769i_discovery.c stm32f769i_discovery_audio.c stm32f769i_discovery_ts.c stm32f769i_discovery_lcd.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
    ../../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../../Drivers/BSP/Components/nt35510/: nt35510.c
  group Application/User/STemWin
    ../STemWin/App/: acceleration_app.c
  group Middlewares/STemWin/OS
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Middlewares/STemWin/Target
    ../STemWin/Target/: GUIConf.c LCDConf.c
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Middlewares/STemWin/lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM7_wc16_ARGB.a
software components: CMSIS:CORE 4.3.0
