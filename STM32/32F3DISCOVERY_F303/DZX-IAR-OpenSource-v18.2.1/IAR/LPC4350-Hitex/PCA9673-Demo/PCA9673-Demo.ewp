# IAR project PCA9673-Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ; ..\..\..\Source\; ..\..\..\Source\Kernel\Port\ARM\M4F\; ..\..\..\Source\MCU\LPC43xx\; ..\..\..\Source\MCU\LPC43xx\M4\; ..\..\..\Source\Demo\LPC4350-Hitex\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: PC9673-Demo.out
  ILINK.IlinkIcfFile: lpc4350_m4.icf
  ILINK.IlinkAdditionalLibs: ..\SDK\Debug\Exe\SDK.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../Source/Demo/LPC4350-Hitex/: board_button.c board_led.c
    ../../../Source/Demo/LPC4350-Hitex/PCA9673-Demo/: main.c
    ../../../Source/Drivers/NXP/: pca9673.c
