# IAR project SDK.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4337_M4 NXP LPC4337_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ; ..\..\..\Source\; ..\..\..\Source\Kernel\Port\ARM\M4F\; ..\..\..\Source\MCU\LPC43xx\; ..\..\..\Source\MCU\LPC43xx\M4\; ..\..\..\Source\Demo\LPC4337-LPCX\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: SDK.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Crypto
    ../../../Source/Crypto/: aes.c crc32.c
  group FS
    ../../../Source/FS/Disk/: disk.c disk_ram.c
  group Kernel
    ../../../Source/Kernel/: kernel_buffer.c kernel_core.c kernel_heap.c kernel_list.c kernel_mutex.c kernel_pool.c kernel_queue.c kernel_semaphore.c kernel_signal.c kernel_stat.c kernel_stopwatch.c kernel_thread.c kernel_timer.c
    ../../../Source/Kernel/Port/ARM/M4F/: kernel_port.c
    ../../../Source/Kernel/Port/ARM/M4F/IAR/: kernel_portasm.s
  group MCU
    ../../../Source/MCU/LPC43xx/: mcu_adc.c mcu_flash.c mcu_hwtimer.c mcu_i2c.c mcu_iap.c mcu_kernel.c mcu_mci.c mcu_pin.c mcu_spi.c mcu_spifi.c mcu_uart.c mcu_usbd.c
    ../../../Source/MCU/LPC43xx/M4/: mcu_irq.c
    ../../../Source/MCU/LPC43xx/M4/IAR/: mcu_start.s
  group USBD
    ../../../Source/USB/Device/: usbd_core.c usbd_dfu.c usbd_endpt.c usbd_intf.c usbd_msc.c usbd_msft.c usbd_string.c
  group Util
    ../../../Source/Util/: slip.c
