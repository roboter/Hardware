<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Gyro-Demo\Gyro-Demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Hello-World\Hello-World.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SDK\SDK.ewp</path>
  </project>
  <batchBuild/>
</workspace>


