# IAR project Backup of Gyro-Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303x6 ST STM32F303x6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ; ..\..\..\Source\; ..\..\..\Source\Kernel\Port\ARM\M4F\; ..\..\..\Source\MCU\STM32F3xx\; ..\..\..\Source\Demo\STM32F303-Disco\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Gyro-Demo.out
  ILINK.IlinkAdditionalLibs: ..\SDK\Debug\Exe\SDK.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../Source/Demo/STM32F303-Disco/: board_led.c
    ../../../Source/Drivers/ST/: l3gd20.c
    ../../../Source/Demo/STM32F303-Disco/Gyro-Demo/: main.c
