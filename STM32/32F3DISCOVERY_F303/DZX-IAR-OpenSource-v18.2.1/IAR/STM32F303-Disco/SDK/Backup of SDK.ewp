# IAR project Backup of SDK.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303R6 ST STM32F303R6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ; ..\..\..\Source\; ..\..\..\Source\Kernel\Port\ARM\M4F\; ..\..\..\Source\MCU\STM32F3xx\; ..\..\..\Source\Demo\STM32F303-Disco\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: SDK.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Crypto
    ../../../Source/Crypto/: aes.c crc32.c
  group Kernel
    ../../../Source/Kernel/: kernel_buffer.c kernel_core.c kernel_heap.c kernel_list.c kernel_mutex.c kernel_pool.c kernel_queue.c kernel_semaphore.c kernel_signal.c kernel_stat.c kernel_stopwatch.c kernel_thread.c kernel_timer.c
    ../../../Source/Kernel/Port/ARM/M4F/: kernel_port.c
    ../../../Source/Kernel/Port/ARM/M4F/IAR/: kernel_portasm.s
  group MCU
    ../../../Source/MCU/STM32F3xx/: mcu_irq.c mcu_kernel.c mcu_pin.c mcu_rcc.c mcu_spi.c
    ../../../Source/MCU/STM32F3xx/IAR/: mcu_start.s
