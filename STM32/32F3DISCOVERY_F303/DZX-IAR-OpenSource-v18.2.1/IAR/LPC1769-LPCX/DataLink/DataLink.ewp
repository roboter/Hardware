# IAR project DataLink.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1769 NXP LPC1769
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ; ..\..\..\Source\; ..\..\..\Source\Kernel\Port\ARM\M3\; ..\..\..\Source\MCU\LPC175x6x\; ..\..\..\Source\Demo\LPC1769-LPCX\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: DataLink.out
  ILINK.IlinkAdditionalLibs: ..\SDK\Debug\Exe\SDK.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../Source/Demo/LPC1769-LPCX/: board_led.c
    ../../../Source/DataLink/: datalink.c datalink_uart.c datalink_usb.c
    ../../../Source/Demo/LPC1769-LPCX/DataLink/: datalink_app.c main.c
