# IAR project SDK.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411VE ST STM32F411VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ; ..\..\..\Source\; ..\..\..\Source\Kernel\Port\ARM\M4F\; ..\..\..\Source\MCU\STM32F4xx\; ..\..\..\Source\Demo\STM32F411-Disco\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: SDK.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Kernel
    ../../../Source/Kernel/: kernel_buffer.c kernel_core.c kernel_heap.c kernel_list.c kernel_mutex.c kernel_pool.c kernel_queue.c kernel_semaphore.c kernel_signal.c kernel_stat.c kernel_stopwatch.c kernel_thread.c kernel_timer.c
    ../../../Source/Kernel/Port/ARM/M4F/: kernel_port.c
    ../../../Source/Kernel/Port/ARM/M4F/IAR/: kernel_portasm.s
  group MCU
    ../../../Source/MCU/STM32F4xx/: mcu_i2c.c mcu_irq.c mcu_kernel.c mcu_pin.c mcu_rcc.c mcu_spi.c
    ../../../Source/MCU/STM32F4xx/IAR/: mcu_start.s
