# IAR project HelloWorld.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1343 NXP LPC1343
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ; ..\..\..\Source\; ..\..\..\Source\Kernel\Port\ARM\M3\; ..\..\..\Source\MCU\LPC13x1x2x3\; ..\..\..\Source\Demo\LPC1343-LPCX\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: HelloWorld.out
  ILINK.IlinkAdditionalLibs: ..\SDK\Debug\Exe\SDK.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../Source/Demo/LPC1343-LPCX/: board_led.c
    ../../../Source/Demo/LPC1343-LPCX/HelloWorld/: main.c
