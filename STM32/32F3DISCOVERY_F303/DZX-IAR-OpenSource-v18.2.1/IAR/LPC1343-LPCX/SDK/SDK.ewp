# IAR project SDK.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1343 NXP LPC1343
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ; ..\..\..\Source\; ..\..\..\Source\Kernel\Port\ARM\M3\; ..\..\..\Source\MCU\LPC13x1x2x3\; ..\..\..\Source\Demo\LPC1343-LPCX\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: SDK.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Crypto
    ../../../Source/Crypto/: aes.c crc32.c
  group Kernel
    ../../../Source/Kernel/: kernel_buffer.c kernel_core.c kernel_heap.c kernel_list.c kernel_mutex.c kernel_pool.c kernel_queue.c kernel_semaphore.c kernel_signal.c kernel_stat.c kernel_stopwatch.c kernel_thread.c kernel_timer.c
    ../../../Source/Kernel/Port/ARM/M3/: kernel_port.c
    ../../../Source/Kernel/Port/ARM/M3/IAR/: kernel_portasm.s
  group MCU
    ../../../Source/MCU/LPC13x1x2x3/: mcu_i2c.c mcu_irq.c mcu_kernel.c mcu_pin.c mcu_spi.c mcu_uart.c mcu_usbd.c
    ../../../Source/MCU/LPC13x1x2x3/IAR/: mcu_start.s
  group USBD
    ../../../Source/USB/Device/: usbd_core.c usbd_dfu.c usbd_endpt.c usbd_intf.c usbd_msc.c usbd_msft.c usbd_string.c
  group Util
    ../../../Source/Util/: slip.c
