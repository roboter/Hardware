<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TMR1_ComplementaryOutput.ewp</path>
    </project>
    <batchBuild />
</workspace>
