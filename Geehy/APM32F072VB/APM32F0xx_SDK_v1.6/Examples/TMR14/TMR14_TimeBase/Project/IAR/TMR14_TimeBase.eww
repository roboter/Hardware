<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TMR14_TimeBase.ewp</path>
    </project>
    <batchBuild />
</workspace>
