# IAR project USB_CDC_VirtualCOMPort.ewp, settings and files
configuration APM32F072 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F072VB Geehy APM32F072VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_APM32F072_MINI; APM32F072xB
  ICCARM.CCIncludePath2: ..\..\Include; ..\..\..\..\..\Board; ..\..\..\..\..\Library\APM32F0xx_StdPeriphDriver\inc; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Device\Geehy\APM32F0xx\Include; ..\..\..\..\..\Library\USB_Device_Lib\Core_Device\Class\CDC\inc; ..\..\..\..\..\Library\USB_Device_Lib\Core_Device\Standard\inc; ..\..\..\..\..\Library\USB_Device_Lib\Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group APP/CDC
    ../../Source/: usb_bsp.c usbd_cdc.c usbd_descriptor.c
    ../../../../../Library/USB_Device_Lib/Core_Device/Class/CDC/src/: usbd_class_cdc.c
  group Application
    ../../Source/: apm32f0xx_int.c main.c
  group Board
    ../../../../../Board/: Board.c
  group CMSIS
    ../../../../../Library/Device/Geehy/APM32F0xx/Source/iar/: startup_apm32f072.s
    ../../../../../Library/Device/Geehy/APM32F0xx/Source/: system_apm32f0xx.c
  group StdPeriphDriver
    ../../../../../Library/APM32F0xx_StdPeriphDriver/src/: apm32f0xx_adc.c apm32f0xx_can.c apm32f0xx_cec.c apm32f0xx_comp.c apm32f0xx_crc.c apm32f0xx_crs.c apm32f0xx_dac.c apm32f0xx_dbg.c apm32f0xx_dma.c apm32f0xx_eint.c apm32f0xx_fmc.c apm32f0xx_gpio.c apm32f0xx_i2c.c apm32f0xx_iwdt.c apm32f0xx_misc.c apm32f0xx_ob.c apm32f0xx_pmu.c apm32f0xx_rcm.c apm32f0xx_rtc.c apm32f0xx_spi.c apm32f0xx_syscfg.c apm32f0xx_tmr.c apm32f0xx_usart.c apm32f0xx_wwdt.c
  group USB_Driver
    ../../../../../Library/USB_Device_Lib/Driver/src/: drv_usb_device.c
  group USB_Protocol
    ../../../../../Library/USB_Device_Lib/Core_Device/Standard/src/: usbd_core.c usbd_init.c usbd_interrupt.c usbd_stdReq.c
