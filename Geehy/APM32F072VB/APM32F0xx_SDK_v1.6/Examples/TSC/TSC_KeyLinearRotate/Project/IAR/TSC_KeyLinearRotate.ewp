# IAR project TSC_KeyLinearRotate.ewp, settings and files
configuration APM32F072 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F072VB Geehy APM32F072VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_APM32F072_MINI; APM32F072xB
  ICCARM.CCIncludePath2: ..\..\Include; ..\..\..\..\..\Library\Device\Geehy\APM32F0xx\Include; ..\..\..\..\..\Library\APM32F0xx_StdPeriphDriver\inc; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\TSC_Device_Lib\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/: apm32f0xx_int.c main.c tsc_user.c
  group CMSIS
    ../../../../../Library/Device/Geehy/APM32F0xx/Source/iar/: startup_apm32f030.s startup_apm32f072.s
    ../../../../../Library/Device/Geehy/APM32F0xx/Source/: system_apm32f0xx.c
  group Hardware
    ../../Source/: delay.c led.c oled.c
  group StdPeriphLib
    ../../../../../Library/APM32F0xx_StdPeriphDriver/src/: apm32f0xx_adc.c apm32f0xx_can.c apm32f0xx_cec.c apm32f0xx_comp.c apm32f0xx_crc.c apm32f0xx_crs.c apm32f0xx_dac.c apm32f0xx_dbg.c apm32f0xx_dma.c apm32f0xx_eint.c apm32f0xx_fmc.c apm32f0xx_gpio.c apm32f0xx_i2c.c apm32f0xx_iwdt.c apm32f0xx_misc.c apm32f0xx_ob.c apm32f0xx_pmu.c apm32f0xx_rcm.c apm32f0xx_rtc.c apm32f0xx_spi.c apm32f0xx_syscfg.c apm32f0xx_tmr.c apm32f0xx_usart.c apm32f0xx_wwdt.c
  group TouchDriver
    ../../../../../Library/TSC_Device_Lib/src/: tsc.c tsc_acq.c tsc_dxs.c tsc_ecs.c tsc_filter.c tsc_linrot.c tsc_object.c tsc_time.c tsc_touchkey.c
